# Keil uVision project 基于Wifi的温湿度测量与传输系统.uvprojx, settings and files
target 基于单片机和WIFI的数据采集与传输系统 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 基于单片机和Wifi的数据采集与传输系统 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\SYSTEM\usart;..\SYSTEM\system;..\SYSTEM\SysTick;..\HARDWARE\WDG;..\HARDWARE\LED;..\HARDWARE\DHT11;..\HARDWARE\RELAY;..\HARDWARE\KEY;..\HARDWARE\ESP8266;..\HARDWARE\OLED;..\HARDWARE\BEEP;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../: readme.txt
  group HARDWARE
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/system/: system.c
    ../SYSTEM/SysTick/: SysTick.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_iwdg.c
